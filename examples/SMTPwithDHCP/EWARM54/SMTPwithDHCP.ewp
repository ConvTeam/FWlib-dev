# IAR project SMTPwithDHCP.ewp, settings and files
configuration WIZ_W7200 (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: PLATFORM_W7200_EVB
  ICCARM.CCIncludePath2: ..\..\..\library; ..\..\..\library\host\STM32F10x\stmlib\CMSIS\CM3\CoreSupport; ..\..\..\library\host\STM32F10x\stmlib\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\..\library\host\STM32F10x\stmlib\STM32F10x_StdPeriph_Driver\inc; ..\src; ..\src-STM32F1xx
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: SMTPwithDHCP.bin
  ILINK.IlinkOutputFile: SMTPwithDHCP.out
  ILINK.IlinkIcfFile: stm32f10x_flash_128k.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration WIZ_W5200 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: PLATFORM_W5200_EVB
  ILINK.IlinkIcfFile: stm32f10x_flash_64k.icf
configuration WIZ_W5500 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: PLATFORM_W5500_EVB
  group Library/appmod
    ../../../library/appmod/loopback/: loopback.c loopback.h
    ../../../library/appmod/usermenu/: usermenu.c usermenu.h
  group Library/common
    ../../../library/common/: common.h types.h util.c util.h
  group Library/device
    ../../../library/device/: socket.h sockutil.c sockutil.h
  group Library/device/w5200
    ../../../library/device/w5200/: socket.c w5200.c w5200.h
  group Library/device/w5500
    ../../../library/device/w5500/: socket.c w5500.c w5500.h
  group Library/host
    ../../../library/host/: wizplatform.h wizspi.h
  group Library/host/STM32F10x
    ../../../library/host/STM32F10x/: wizspi.c
  group Library/host/STM32F10x/stmlib
    ../../../library/host/STM32F10x/stmlib/CMSIS/CM3/CoreSupport/: core_cm3.c core_cm3.h
    ../../../library/host/STM32F10x/stmlib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
    ../../../library/host/STM32F10x/stmlib/STM32F10x_StdPeriph_Driver/inc/: misc.h stm32f10x_flash.h stm32f10x_gpio.h stm32f10x_rcc.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h
    ../../../library/host/STM32F10x/stmlib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_md.s
  group Library/host/STM32F10x/WIZ_W5200
    ../../../library/host/STM32F10x/WIZ_W5200/: system_stm32f10x.c w5200_evb.h wizplatform.c
  group Library/host/STM32F10x/WIZ_W5500
    ../../../library/host/STM32F10x/WIZ_W5500/: system_stm32f10x.c w5500_evb.h wizplatform.c
  group Library/host/STM32F10x/WIZ_W7200
    ../../../library/host/STM32F10x/WIZ_W7200/: system_stm32f10x.c w7200_evb.h wizplatform.c
  group Library/protocol
    ../../../library/protocol/DHCP/: dhcp.c dhcp.h
    ../../../library/protocol/DNS/: dns.c dns.h
    ../../../library/protocol/SMTP/: smtp.c smtp.h
  group User
    ../src/: main.c wizconfig.h
  group User/src-STM32F1xx
    ../src-STM32F1xx/: stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
