# IAR project Serial2Ethernet.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCIncludePath2: ..\..\..\library; ..\..\..\library\host\STM32F10x\stmlib\CMSIS\CM3\CoreSupport; ..\..\..\library\host\STM32F10x\stmlib\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\..\library\host\STM32F10x\stmlib\STM32F10x_StdPeriph_Driver\inc; ..\src; port
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: Serial2Ethernet.bin
  ILINK.IlinkOutputFile: Serial2Ethernet.out
  ILINK.IlinkIcfFile: E:\_user\Desktop\FW라이브러리\WIZLib-work\examples\Serial2Ethernet\EWARM-STM32F1xx\stm32f10x_flash_128k_S2E.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: dl-stnl0.a
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Library/appmod
    ../../../library/appmod/atcmd/: atcmd.c cmdrun.c
  group Library/common
    ../../../library/common/: util.c
  group Library/device
    ../../../library/device/w5200/: socket.c w5200.c
    ../../../library/device/: sockutil.c
  group Library/host
    ../../../library/host/STM32F10x/WIZ_W7200/: system_stm32f10x.c wizplatform.c
    ../../../library/host/STM32F10x/: wizspi.c
  group Library/host/stmlib
    ../../../library/host/STM32F10x/stmlib/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../../library/host/STM32F10x/stmlib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c
    ../../../library/host/STM32F10x/stmlib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_md.s
  group Library/protocol
    ../../../library/protocol/DHCP/: dhcp.c
    ../../../library/protocol/DNS/: dns.c
  group User
    ../src/: main.c
  group User/port
    port/: stm32f10x_it.c
