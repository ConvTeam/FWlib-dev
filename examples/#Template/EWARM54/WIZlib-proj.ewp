# IAR project WIZlib-proj.ewp, settings and files
configuration W7200_EVB (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: PLATFORM_W7200_EVB
  ICCARM.CCIncludePath2: ..\..\..\library; ..\..\..\library\host\STM32F10x\stmlib\CMSIS\CM3\CoreSupport; ..\..\..\library\host\STM32F10x\stmlib\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\..\library\host\STM32F10x\stmlib\STM32F10x_StdPeriph_Driver\inc; ..\..\..\library\host\STM32F10x\WIZ_W7200; ..\src; ..\src-STM32F1xx
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: WIZlib-proj.bin
  ILINK.IlinkOutputFile: WIZlib-proj.out
  ILINK.IlinkIcfFile: stm32f10x_flash_128k.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration W5200_EVB (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: PLATFORM_W5200_EVB
  ICCARM.CCIncludePath2: ..\..\..\library; ..\..\..\library\host\STM32F10x\stmlib\CMSIS\CM3\CoreSupport; ..\..\..\library\host\STM32F10x\stmlib\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\..\library\host\STM32F10x\stmlib\STM32F10x_StdPeriph_Driver\inc; ..\..\..\library\host\STM32F10x\WIZ_W5200; ..\src; ..\src-STM32F1xx
  ILINK.IlinkIcfFile: stm32f10x_flash_64k.icf
configuration W5500_EVB (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: PLATFORM_W5500_EVB
  ICCARM.CCIncludePath2: ..\..\..\library; ..\..\..\library\host\STM32F10x\stmlib\CMSIS\CM3\CoreSupport; ..\..\..\library\host\STM32F10x\stmlib\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\..\library\host\STM32F10x\stmlib\STM32F10x_StdPeriph_Driver\inc; ..\..\..\library\host\STM32F10x\WIZ_W5500; ..\src; ..\src-STM32F1xx
  group Library/appmod/atcmd
    ../../../library/appmod/atcmd/: atcmd.c atcmd.h cmdrun.c cmdrun.h
  group Library/appmod/loopback
    ../../../library/appmod/loopback/: loopback.c loopback.h
  group Library/appmod/usermenu
    ../../../library/appmod/usermenu/: usermenu.c usermenu.h
  group Library/common
    ../../../library/common/: common.h types.h util.c util.h
  group Library/device
    ../../../library/device/: netctrl.h socket.h sockutil.c sockutil.h
  group Library/device/w5200
    ../../../library/device/w5200/: netctrl.c socket.c w5200.c w5200.h
  group Library/device/w5500
    ../../../library/device/w5500/: netctrl.c socket.c w5500.c w5500.h
  group Library/host
    ../../../library/host/: wizplatform.h
  group Library/host/STM32F10x/stmlib/CMSIS
    ../../../library/host/STM32F10x/stmlib/CMSIS/CM3/CoreSupport/: core_cm3.c core_cm3.h
    ../../../library/host/STM32F10x/stmlib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_md.s
    ../../../library/host/STM32F10x/stmlib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Library/host/STM32F10x/stmlib/StdPeriph_Driver
    ../../../library/host/STM32F10x/stmlib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ../../../library/host/STM32F10x/stmlib/STM32F10x_StdPeriph_Driver/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group Library/host/STM32F10x/WIZ_W5200
    ../../../library/host/STM32F10x/WIZ_W5200/: stmlib_config.h w5200_evb.h wizplatform.c
  group Library/host/STM32F10x/WIZ_W5500
    ../../../library/host/STM32F10x/WIZ_W5500/: stmlib_config.h w5500_evb.h wizplatform.c
  group Library/host/STM32F10x/WIZ_W7200
    ../../../library/host/STM32F10x/WIZ_W7200/: stmlib_config.h w7200_evb.h wizplatform.c
  group Library/protocol/DHCP
    ../../../library/protocol/DHCP/: dhcp.c dhcp.h
  group Library/protocol/DNS
    ../../../library/protocol/DNS/: dns.c dns.h
  group Library/protocol/HTTP
    ../../../library/protocol/HTTP/: httpd.c httpd.h httputil.c httputil.h
  group Library/protocol/SMTP
    ../../../library/protocol/SMTP/: smtp.c smtp.h
  group User
    ../src/: main.c wizconfig.h
  group User/src-STM32F1xx
    ../src-STM32F1xx/: stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
