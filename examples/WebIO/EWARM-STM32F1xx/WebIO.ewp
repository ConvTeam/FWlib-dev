# IAR project WebIO.ewp, settings and files
configuration WIZ_W7200 (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCIncludePath2: ..\..\..\library; ..\..\..\library\host\STM32F10x\stmlib\CMSIS\CM3\CoreSupport; ..\..\..\library\host\STM32F10x\stmlib\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\..\library\host\STM32F10x\stmlib\STM32F10x_StdPeriph_Driver\inc; ..\src; port
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: WebIO.bin
  ILINK.IlinkOutputFile: WebIO.out
  ILINK.IlinkIcfFile: stm32f10x_flash_128k.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Library/appmod
    ../../../library/appmod/loopback/: loopback.c
    ../../../library/appmod/usermenu/: usermenu.c
  group Library/common
    ../../../library/common/: util.c
  group Library/device
    ../../../library/device/w5200/: socket.c w5200.c
    ../../../library/device/: sockutil.c
  group Library/host
    ../../../library/host/STM32F10x/WIZ_W7200/: system_stm32f10x.c wizplatform.c
    ../../../library/host/STM32F10x/: wizspi.c
  group Library/host/stmlib
    ../../../library/host/STM32F10x/stmlib/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../../library/host/STM32F10x/stmlib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_bkp.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
    ../../../library/host/STM32F10x/stmlib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_md.s
  group Library/protocol
    ../../../library/protocol/DHCP/: dhcp.c
    ../../../library/protocol/DNS/: dns.c
    ../../../library/protocol/HTTP/: httpd.c httputil.c
  group User
    ../src/: main.c romfile.c
  group User/port
    port/: stm32f10x_it.c
